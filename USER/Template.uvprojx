# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\DEVICE_LIB\inc;..\SYSTEM;..\HEADWARE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../CMSIS/: startup_stm32f10x_md.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_iwdg.c
  group HEADWARE
    ../HEADWARE/: delay.c led.c key.c exti.c timer.c pwm.c usart.c beep.c OLED_I2C.c photoresistor.c adjr.c servo.c iwdg.c wwdg.c
  group SYSTEM
    ../SYSTEM/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h system.h
  group USER
    ./: main.c stm32f10x_it.c
